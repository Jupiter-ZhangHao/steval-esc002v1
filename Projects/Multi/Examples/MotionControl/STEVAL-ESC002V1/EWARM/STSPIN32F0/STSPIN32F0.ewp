# IAR project STSPIN32F0.ewp, settings and files
configuration STSPIN32F0A_ESC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_ESC002V1; USE_HAL_DRIVER; STM32F031x6; NO_UART_COMM; ST_PWM_INTERFACE; ARR_FILTER; SENSE_COMPARATORS; NO_OPEN_LOOP_RAMP; NO_VARIABLE_ADVANCE; FAST_DEMAG; PID_V2; OPEN_LOOP; MC_7PP_3S_PROPELLER; DELTA_6STEP_TABLE; COMPLEMENTARY_DRIVE; VOLTAGE_MODE; SPEED_SENDING; SPEED_RAMP
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STEVAL-ESC002V1; ..\..\..\..\..\..\..\Drivers\BSP\Components\stspin32f0; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM_STSPIN32F0A_ESC.bin
  ILINK.IlinkOutputFile: STSPIN32F0.out
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/stspin32f0/: stspin32f0.c
  group Drivers/BSP/STEVAL-ESC002V1
    ../../../../../../../Drivers/BSP/STEVAL-ESC002V1/: STEVAL-ESC002V1.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
  group Example/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f031x6.s
  group Example/User
    ../../Src/: main_32F0.c stspin32f0_hal_msp.c stspin32f0_it.c
    ../../Inc/: MC_SixStep_param_7PP_3S_propeller.h
  group Middlewares/MC_6Step_Lib
    ../../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
